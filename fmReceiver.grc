options:
  parameters:
    author: aharon
    generate_options: qt_gui
    id: secondFlowGraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Station Select
    labels: '["Galei Tzahal", "Radio Lev HaMedina", "Radio Kol Chai"]'
    num_opts: '0'
    options: '[9.9e7, 9.1e7, 9.3e7]'
    orient: Qt.QHBoxLayout
    type: real
    value: 9.9e7
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /Users/aharon/Desktop/לימודים/שנה ג/סמסטר ב/מבוא לרדיו תוכנה/מטלה 1/Audio_record.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Waterfall Display
    type: complex
    update_time: '0.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
